# Keil uVision project BlackFly.uvprojx, settings and files
target BlackFly (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlackFly +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Project;..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\PS2;..\PARAMETER;..\HARDWARE\TIMING;..\HARDWARE\GPIO;..\HARDWARE\MOTOR;..\HARDWARE\SPI3;..\HARDWARE\MPU6050;..\HARDWARE\IMU_AHRS;..\MY_MATH\MathTool;..\MY_MATH;..\CONTROL;..\HARDWARE\TOF;..\HARDWARE\SBUS;..\HARDWARE\ADC;..\HARDWARE\OLED;..\HARDWARE\u8g2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/PS2/: ps2.c
    ../HARDWARE/TIMING/: timing.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/SPI3/: spi3.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/IMU_AHRS/: imu_AHRS.c
    ../HARDWARE/TOF/: usart5tof.c
    ../HARDWARE/SBUS/: sbus.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/OLED/: Oled.c
  group PARAMETER
    ../PARAMETER/: parameter.h
  group Mymath
    ../MY_MATH/MathTool/: math_tool.c
    ../MY_MATH/: digital_filter.c MahonyAHRS.c limit.c PositionEstimation.c
  group CONTROL
    ../CONTROL/: pid.c position.c attitude.c
  group u8g2
    ../HARDWARE/u8g2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c u8x8_d_ssd1306_128x64_noname.c
